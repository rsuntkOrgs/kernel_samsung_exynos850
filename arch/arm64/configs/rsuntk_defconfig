## arch/arm64/configs/rsuntk_defconfig
```kconfig
CONFIG_LOCALVERSION="-Rissu"
CONFIG_EROFS_FS=y
CONFIG_DISABLE_TRACE_PRINTK=y
# CONFIG_DEBUG_KERNEL is not set
# CONFIG_AUDIT is not set
```
